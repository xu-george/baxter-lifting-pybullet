Commit message: only position based grasp

File: baxter_bullet_env/models/objects/block/model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: mass 0.2 -> 0.05
